# IAR project hello_world.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL27Z64xxx4 Freescale MKL27Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL27Z64VLH4; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; FRDM_KL27Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKL27Z644/drivers; ..; ../../../../../devices/MKL27Z644/utilities; ../../..; ../../../../../devices/MKL27Z644; ..\CMSIS USB Stack\inc; ..\CMSIS USB Stack\Porting use; ..\SPI_SDCard
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MKL27Z64xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL27Z64VLH4; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; FRDM_KL27Z; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKL27Z644/drivers; ..; ../../../../../devices/MKL27Z644/utilities; ../../..; ../../../../../devices/MKL27Z644
  ICCARM.CCOptLevel: 3
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL27Z644/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dma.c fsl_dma.h fsl_dmamux.c fsl_dmamux.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_uart.c fsl_uart.h
  group source
    ../: disk.c disk.h
  group spi_sdcard
    ../SPI_SDCard/: fsl_sdcard_spi.c fsl_sdcard_spi.h SPI_kinetis.c SPI_kinetis.h
  group startup
    ../../../../../devices/MKL27Z644/iar/: startup_MKL27Z644.s
    ../../../../../devices/MKL27Z644/: system_MKL27Z644.c system_MKL27Z644.h
  group usbstack
    ../CMSIS USB Stack/Porting use/: usb_config.h usb_lib.c usbd_KL27.c
    ../CMSIS USB Stack/src/: usbd_core.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group utilities
    ../../../../../devices/MKL27Z644/utilities/: fsl_debug_console.c fsl_debug_console.h
